# Keil uVision project HelTec_103RC.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HelTec +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\_2_USER;.\_3_SYSTEM;.\_4_HARDWARE;.\_5_APP;.\_7_COMPA;.\_0_FWLib\CMSIS;.\_0_FWLib\inc;.\_0_FWLib\src;.\_8_DATA
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group APP
    ./_5_APP/: Light_Transfer.c
  group USER
    ./_2_USER/: com.c main.c
  group HARDWARE
    ./_4_HARDWARE/: GPIO.c IRQ.c ADC.c DAC.c PWM.c
  group SYSTEM
    ./_3_SYSTEM/: delay.c sys.c
  group COMPA
    ./_7_COMPA/: OLED.c flash.c
  group DATA
    ./_8_DATA/: codetab.h
  group FWLIB
    ./_0_FWLib/CMSIS/startup/: startup_stm32f10x_hd.s
    ./_0_FWLib/CMSIS/: system_stm32f10x.c core_cm3.c
    ./_0_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DOC
    ./_6_DOC/: 示例.txt
