# Keil uVision project WindOS.uvproj, settings and files
target WindOS (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WindOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\_01_App;.\_02_User;.\_03_OS;.\_04_System;.\_05_Drive;.\_06_Library\inc;.\_07_Doc;.\_08_Material;.\_06_Library\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  group App
    ./_01_App/: App_Test.c App_LED.c App_Message.c App_Key.c
  group User
    ./_02_User/: main.c User_Library.h
  group OS
    ./_03_OS/: OS_StartFile.c OS_Manage.c OS_Run.c OS_UI.c
  group System
    ./_04_System/: sys.c
  group Drive
    ./_05_Drive/: Drive_GPIO.c Drive_OLED.c Drive_Timer.c Drive_EXTI.c Drive_Interrupt.c Drive_ADC.c Drive_DAC.c Drive_Message.c Drive_Bootload.c
  group Library
    ./_06_Library/CMSIS/: startup_stm32f10x_hd.s system_stm32f10x.c core_cm3.c
    ./_06_Library/src/: misc.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_dac.c stm32f10x_dma.c
  group Doc
    ./: ReadMe.txt
