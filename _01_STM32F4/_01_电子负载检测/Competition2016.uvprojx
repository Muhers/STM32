# Keil uVision project Competition2016.uvprojx, settings and files
target Master2017 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Competition2016
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT = 1,__FPU_USED=1
  c include: .\_01_App;.\_02_User;.\_03_OS;.\_04_System;.\_05_Drive\_01_TFT5;.\_05_Drive;.\_06_Library;.\_08_Material;.\_06_Library\inc;.\_06_Library\Start;.\_05_Drive\OLED
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1ffff
  memory RVCT10: RAM 0x10000000 size 0xffff
  group App
    ./_01_App/: App_UI_Operation.c App_LoadMeasure.c App_Message.c App_Key.c App_LED.c App_Test.c
  group User
    ./_02_User/: main.c User_Stdafx.h User_Library.h
  group OS
    ./_03_OS/: OS_Run.c OS_Manage.c OS_StartFile.c OS_UI.c
  group System
    ./_04_System/: delay.c my_sys.c sys.c
  group Drive
    ./_05_Drive/: Drive_LoadAnalysis.c Drive_LoadMeasure.c Drive_Message.c Drive_DataSave.c Drive_Bluetooth.c Drive_Usart.c Drive_FreqMeasure.c Drive_Filter.c Drive_ADS1271.c Drive_Interrupt.c PS2.c Drive_FFT.c Drive_IIC.c Drive_GPIO.c Drive_Exti.c Drive_Timer.c Drive_Flash.c Drive_DMA.c Drive_PWM.c Drive_ADC.c Drive_DAC.c Drive_Touch.c
    ./_05_Drive/OLED/: OLED.c flash.c
  group Library
    ./_06_Library/Start/: startup_stm32f40_41xxx.s arm_cortexM4lf_math.lib stm32f4xx_it.c system_stm32f4xx.c
    ./_06_Library/src/: stm32f4xx_rcc.c misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group TFT
    ./_05_Drive/_01_TFT5/: TFT_LCD.c W25Q64.c Character.c fonts.c spi.c text.c fontupd.c
  group Doc
    ./: ReadMe.txt
  group Material
    ./_08_Material/: Material.h
