# Keil uVision project uCOS-III.uvprojx, settings and files
target Project (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uCOS-III
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  c include: .\_01_App;.\_02_User;.\_04_System;.\_05_Drive;.\_06_Library\inc;.\_06_Library\Start;.\_05_Drive\_01_AlientekTFT;.\_03_uCOS-III\uC-LIB;.\_03_uCOS-III\uC-CPU;.\_03_uCOS-III;.\_03_uCOS-III\uCOS_BSP;.\_03_uCOS-III\uCOS_CONFIG;.\_03_uCOS-III\uCOS-III\Source;.\_03_uCOS-III\uC-CPU\ARM-Cortex-M4\RealView;.\_03_uCOS-III\uC-LIB\Ports\ARM-Cortex-M4\RealView;.\_03_uCOS-III\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;.\_08_emWin\STemWin\inc;.\_08_emWin\STemWin\Config;.\_08_emWin\Demo;.\_08_emWin\GUIBuilder
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ./_01_App/: App_LED.c App_Test.c App_emWinTest.c App_Include.h
  group User
    ./_02_User/: main.c OS_Start.c User_Include.h
  group System
    ./_04_System/: delay.c malloc.c sram.c sys.c usart.c
  group Drive
    ./_05_Drive/: Drive_Timer.c Drive_Interrupt.c Drive_GPIO.c Drive_Exti.c Drive_UI.c
  group Library
    ./_06_Library/Start/: arm_cortexM4lf_math.lib startup_stm32f40_41xxx.s system_stm32f4xx.c stm32f4xx_it.c core_cm4.h
    ./_06_Library/src/: stm32f4xx_syscfg.c misc.c stm32f4xx_rtc.c stm32f4xx_rcc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_i2c.c stm32f4xx_sdio.c stm32f4xx_spi.c
  group TFT
    ./_05_Drive/_01_AlientekTFT/: 24cxx.c ctiic.c ft5206.c gt9147.c ILI93xx.c myiic.c ott2001a.c touch.c
  group uCOS_Bsp
    ./_03_uCOS-III/uCOS_BSP/: bsp.c
  group uCOS_Config
    ./_03_uCOS-III/uCOS_CONFIG/: app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h includes.h
  group uC-CPU
    ./_03_uCOS-III/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
    ./_03_uCOS-III/uC-CPU/: cpu_core.c
  group uC-LIB
    ./_03_uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./_03_uCOS-III/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uCOS-III
    ./_03_uCOS-III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ./_03_uCOS-III/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group emWin
    ./_08_emWin/STemWin/Config/: GUIConf.c GUI_X_Touch_Analog.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ./_08_emWin/STemWin/OS/: GUI_X_UCOSIII.c
    ./_08_emWin/STemWin/Lib/: STemWin526_CM4_OS_Keil.lib
  group emWin GUIBuilder
    ./_08_emWin/GUIBuilder/: WindowDLG.c FramewinDLG.c
